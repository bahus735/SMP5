# Keil uVision project LCD.uvprojx, settings and files
target CMSIS-DAP (ARM-ADS)
  device: MKL25Z128xxx4 NXP
  pack: Keil.Kinetis_KLxx_DFP.1.15.0
  cpu: IROM(0x00000000,0x00020000) IRAM(0x1FFFF000,0x00004000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: LCD
  c flags: Optim=1 OneElfS=1 wLevel=2
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x1ffff000 size 0x4000
  group src
    ./: main.c leds.c lowpower.c spi.c epaper.c epaper.h display.c I2C.c stml75.c font8x8.c LPS331AP.c HTS221.c PIT.c
software components: CMSIS:CORE 4.1.0, Device:Startup 2.5.0
